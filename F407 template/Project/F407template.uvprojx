# Keil uVision project F407template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_USB_OTG_FS,ARM_MATH_CM4,__FPU_PRESENT=1,HSE_VALUE=8000000
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Project;..\system;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM4F;..\bsp\inc;..\CanFestival\inc;..\CanFestival\inc\stm32;..\CanFestival\objdict;..\tasks\inc;..\FatFS;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c FreeRTOSConfig.h includes.h sys.c SysInfoTest.c
  group bsp
    ../bsp/src/: bsp.c led.c template.c usartdma.c bsp_key.c sdio_sdcard.c bsp_tim_pwm.c w25qxx.c spi.c bsp_dwt.c
  group tasks
    ../tasks/src/: can_thread.c usart_thread.c epos2_thread.c sys_timer.c appdata.c FatFS_thread.c RWdata_thread.c
  group Objdict
    ../CanFestival/objdict/: OD_NODE1.c OD_NODE2.c
  group system
    ../system/: stm32f4xx_it.c system_stm32f4xx.c
  group startup
    ../startup/: startup_stm32f40xx.s
  group freeRTOS/Source
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freeRTOS/Ports
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group canfestival
    ../CanFestival/driver/: can_STM32.c timer_STM32.c
    ../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c symbols.c sync.c timer.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_des.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FatFS
    ../FatFS/: diskio.c ff.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USBD_MSC
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USBD_CDC
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbd_cdc_vcp.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
